# Keil uVision project project1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\Basic\delay;.\Basic\flash;.\Basic\rtc;.\Basic\sys;.\Basic\usart;.\CMSIS;.\Hardware\BUZZER;.\Hardware\KEY;.\Hardware\LED;.\Lib\inc;.\Lib\src;.\Startup;.\User;.\Hardware\TOUCH_KEY;.\Hardware\TM1640;.\Basic\i2c;.\Hardware\LM75A
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Basic
    ./Basic/delay/: delay.c
    ./Basic/flash/: flash.c
    ./Basic/rtc/: rtc.c
    ./Basic/sys/: sys.c
    ./Basic/usart/: usart.c
    ./Basic/i2c/: i2c.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group HardWare
    ./Hardware/BUZZER/: buzzer.c
    ./Hardware/KEY/: key.c
    ./Hardware/LED/: led.c
    ./Hardware/TOUCH_KEY/: touch_key.c
    ./Hardware/TM1640/: tm1640.c
    ./Hardware/LM75A/: lm75a.c
  group Lib
    ./Lib/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_usart.c stm32f10x_i2c.c
  group Startup
    ./Startup/: startup_stm32f10x_md.s
  group User
    ./User/: main.c stm32f10x_it.c
